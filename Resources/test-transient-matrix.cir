Test transient circuit file for NGSpice.  2/4/2017
* Testing transient modelling with a capacitor
* The RC time constant is 680ohms * 1 uF = 0.68ms

*
*
*  A1 11 21 31 41 51 61 71 81  B91
*   2 12 22 32 42 52 62 72 82   92
*   3 13 23 33 43 53 63 73 83   93
*   4 14 24 34 44 54 64 74 84   94
*   5 15 25 35 45 55 65 75 85   95
*   6 16 26 36 46 56 66 76 86   96
*   7 17 27 37 47 57 67 77 87   97
*   8 18 28 38 48 58 68 78 88   98
*   9 19 29 39 49 59 69 79 89   99
* C10 20 30 40 50 60 70 80 90 D100
*

* 1-10
r001_002 1 2 10e3
r002_003 2 3 10e3
r003_004 3 4 10e3
r004_005 4 5 10e3
r005_006 5 6 10e3
r006_007 6 7 10e3
r007_008 7 8 10e3
r008_009 8 9 10e3
r009_010 9 10 10e3

* 11-20
r011_012 11 12 10e3
r012_013 12 13 10e3
r013_014 13 14 10e3
r014_015 14 15 10e3
r015_016 15 16 10e3
r016_017 16 17 10e3
r017_018 17 18 10e3
r018_019 18 19 10e3
r019_020 19 20 10e3

* 21-30
r021_022 21 22 10e3
r022_023 22 23 10e3
r023_024 23 24 10e3
r024_025 24 25 10e3
r025_026 25 26 10e3
r026_027 26 27 10e3
r027_028 27 28 10e3
r028_029 28 29 10e3
r029_030 29 30 10e3

* 31-40
r031_032 31 32 10e3
r032_033 32 33 10e3
r033_034 33 34 10e3
r034_035 34 35 10e3
r035_036 35 36 10e3
r036_037 36 37 10e3
r037_038 37 38 10e3
r038_039 38 39 10e3
r039_040 39 40 10e3

* 41-50
r041_042 41 42 10e3
r042_043 42 43 10e3
r043_044 43 44 10e3
r044_045 44 45 10e3
r045_046 45 46 10e3
r046_047 46 47 10e3
r047_048 47 48 10e3
r048_049 48 49 10e3
r049_050 49 50 10e3

* 51-60
r051_052 51 52 10e3
r052_053 52 53 10e3
r053_054 53 54 10e3
r054_055 54 55 10e3
r055_056 55 56 10e3
r056_057 56 57 10e3
r057_058 57 58 10e3
r058_059 58 59 10e3
r059_060 59 60 10e3

* 61-70
r061_062 61 62 10e3
r062_063 62 63 10e3
r063_064 63 64 10e3
r064_065 64 65 10e3
r065_066 65 66 10e3
r066_067 66 67 10e3
r067_068 67 68 10e3
r068_069 68 69 10e3
r069_070 69 70 10e3

* 71-80
r071_072 71 72 10e3
r072_073 72 73 10e3
r073_074 73 74 10e3
r074_075 74 75 10e3
r075_076 75 76 10e3
r076_077 76 77 10e3
r077_078 77 78 10e3
r078_079 78 79 10e3
r079_080 79 80 10e3

* 81-90
r081_082 81 82 10e3
r082_083 82 83 10e3
r083_084 83 84 10e3
r084_085 84 85 10e3
r085_086 85 86 10e3
r086_087 86 87 10e3
r087_088 87 88 10e3
r088_089 88 89 10e3
r089_090 89 90 10e3

* 91-100
r091_092 91 92 10e3
r092_093 92 93 10e3
r093_094 93 94 10e3
r094_095 94 95 10e3
r095_096 95 96 10e3
r096_097 96 97 10e3
r097_098 97 98 10e3
r098_099 98 99 10e3
r099_100 99 100 10e3

* 1-91
r001_011 1 11 10e3
r011_021 11 21 10e3
r021_031 21 31 10e3
r031_041 31 41 10e3
r041_051 41 51 10e3
r051_061 51 61 10e3
r061_071 61 71 10e3
r071_081 71 81 10e3
r081_091 81 91 10e3

* 2-92
r002_012 2 12 10e3
r012_022 12 22 10e3
r022_032 22 32 10e3
r032_042 32 42 10e3
r042_052 42 52 10e3
r052_062 52 62 10e3
r062_072 62 72 10e3
r072_082 72 82 10e3
r082_092 82 92 10e3

* 3-93
r003_013 3 13 10e3
r013_023 13 23 10e3
r023_033 23 33 10e3
r033_043 33 43 10e3
r043_053 43 53 10e3
r053_063 53 63 10e3
r063_073 63 73 10e3
r073_083 73 83 10e3
r083_093 83 93 10e3

* 4-94
r004_014 4 14 10e3
r014_024 14 24 10e3
r024_034 24 34 10e3
r034_044 34 44 10e3
r044_054 44 54 10e3
r054_064 54 64 10e3
r064_074 64 74 10e3
r074_084 74 84 10e3
r084_094 84 94 10e3

* 5-95
r005_015 5 15 10e3
r015_025 15 25 10e3
r025_035 25 35 10e3
r035_045 35 45 10e3
r045_055 45 55 10e3
r055_065 55 65 10e3
r065_075 65 75 10e3
r075_085 75 85 10e3
r085_095 85 95 10e3

* 6-96
r006_016 6 16 10e3
r016_026 16 26 10e3
r026_036 26 36 10e3
r036_046 36 46 10e3
r046_056 46 56 10e3
r056_066 56 66 10e3
r066_076 66 76 10e3
r076_086 76 86 10e3
r086_096 86 96 10e3

* 7-97
r007_017 7 17 10e3
r017_027 17 27 10e3
r027_037 27 37 10e3
r037_047 37 47 10e3
r047_057 47 57 10e3
r057_067 57 67 10e3
r067_077 67 77 10e3
r077_087 77 87 10e3
r087_097 87 97 10e3

* 8-98
r008_018 8 18 10e3
r018_028 18 28 10e3
r028_038 28 38 10e3
r038_048 38 48 10e3
r048_058 48 58 10e3
r058_068 58 68 10e3
r068_078 68 78 10e3
r078_088 78 88 10e3
r088_098 88 98 10e3

* 9-99
r009_019 9 19 10e3
r019_029 19 29 10e3
r029_039 29 39 10e3
r039_049 39 49 10e3
r049_059 49 59 10e3
r059_069 59 69 10e3
r069_079 69 79 10e3
r079_089 79 89 10e3
r089_099 89 99 10e3

* 10-100
r010_020 10 20 10e3
r020_030 20 30 10e3
r030_040 30 40 10e3
r040_050 40 50 10e3
r050_060 50 60 10e3
r060_070 60 70 10e3
r070_080 70 80 10e3
r080_090 80 90 10e3
r090_100 90 100 10e3

* Capacitors
c1 76 0 50e-12
c2 77 0 50e-12
c3 86 0 50e-12
c4 87 0 50e-12

xA 1 sensor
xB 91 sensor
xC 10 sensor
xD 100 sensor

.subckt sensor n2
	vA n1 0 dc 0 sin(0V 5V 10kHz 0 0)
	rA n1 n2 1e5 $ 100KOhm
	cpA n2 0 40e-12
.ends

.control
	tran 1e-6 1e-3
	write testoutmatrix.raw all
.endc

.end
